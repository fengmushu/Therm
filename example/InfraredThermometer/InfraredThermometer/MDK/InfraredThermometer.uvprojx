# Keil uVision project InfraredThermometer.uvprojx, settings and files
target InfraredThermometer_Release (6130001::V6.13.1::.\ARMCLANG)
  device: HC32L136J8TA HDSC
  pack: HDSC.HC32L136.1.0.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: InfraredThermometer +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;..\..\..\..\midware\inc;..\..\..\..\midware\ssd1306\src
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../../../../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c adc.c gpio.c bgr.c lcd.c lvd.c pca.c wdt.c rtc.c lpm.c uart.c flash.c crc.c i2c.c timer3.c spi.c
  group midware
    ../../../../midware/src/: app_gpio.c app_adc.c app.c tnna.c app_i2c.c app_cal.c app_key.c app_fn.c fsm_core.c fsm_event_ring.c fsm_states.c app_data.c app_main.c app_timer.c app_rtc.c app_factory.c app_spi.c app_lcd.cpp
    ../../../../midware/ssd1306/src/: ssd1306_generic.c ssd1306_1bit.c ssd1306_8bit.c ssd1306_16bit.c ssd1306_fonts.c ssd1306_menu.c ssd1306_uart.c nano_gfx.cpp sprite_pool.cpp ssd1306_console.cpp
    ../../../../midware/ssd1306/src/lcd/: lcd_common.c oled_ssd1306.c
    ../../../../midware/ssd1306/src/intf/: ssd1306_interface.c
    ../../../../midware/ssd1306/src/intf/spi/: ssd1306_spi.c
    ../../../../midware/ssd1306/src/intf/i2c/: ssd1306_i2c.c
    ../../../../midware/ssd1306/src/ssd1306_hal/template/: platform.c
    ../../../../midware/ssd1306/src/nano_engine/: canvas.cpp core.cpp
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
